# Keil uVision project bluepill_keil-blinky.uvproj, settings and files
target BluePill (F103C8) (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: bluepill_keil-blinky +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\Sources;.\Sources\CMSIS;.\Sources\SPL;.\Sources\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Sources/: startup_stm32f10x_md.s
  group CMSIS
    ./Sources/CMSIS/: system_stm32f10x.c core_cm3.c system_stm32f10x.h stm32f10x.h
  group SPL
    ./Sources/SPL/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./Sources/include/: stm32f10x_conf.h
  group Sources
    ./Sources/: main.c
